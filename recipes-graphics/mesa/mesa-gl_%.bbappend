do_install:append:stm32mpcommon() {
    rm -rf ${D}/usr/include/KHR
}
