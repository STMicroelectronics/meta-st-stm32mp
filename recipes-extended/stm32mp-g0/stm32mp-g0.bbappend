# Add STM32MP G0 firmware
SRC_URI:append = " file://${STM32MP_G0_FW};subdir=git/Projects/STM32MP135F-DK/Applications/USB_PD/UCSI_DRP/Binary "
