SUMMARY = "STM32MP2 Firmware examples for CM33"
LICENSE = "Apache-2.0 & MIT & BSD-3-Clause"

require recipes-extended/stm32mp2-projects/mxxprojects-stm32mp2-common.inc
require recipes-extended/stm32mp2-projects/m33projects.inc
