SRC_URI += " \
     file://0099-Modify-Reset-reason-trace-level.patch \
     "
