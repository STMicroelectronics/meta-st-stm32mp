# make-mode-scripts package -dev and -dbg are empty so don't generate them
ALLOW_EMPTY_${PN}-dev = "0"
ALLOW_EMPTY_${PN}-dbg = "0"
