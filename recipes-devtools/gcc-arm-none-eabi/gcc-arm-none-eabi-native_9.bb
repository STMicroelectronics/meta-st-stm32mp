SUMMARY = "Baremetal GCC for ARM"
LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

require gcc-arm-none-eabi_${PV}.inc

inherit native
