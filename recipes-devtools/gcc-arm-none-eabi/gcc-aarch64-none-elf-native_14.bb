SUMMARY = "Baremetal GCC for ARM aarch64"
LICENSE = "GPL-3.0-with-GCC-exception & GPL-3.0-only"

require gcc-aarch64-none-elf_${PV}.inc

inherit native
