SRC_URI_append_stm32mpcommon = " file://0001-SDK-Add-relative-path-for-cmsis-svd.patch"
# Add the same for nativesdk
SRC_URI_append_class-nativesdk = " file://0001-SDK-Add-relative-path-for-cmsis-svd.patch"
