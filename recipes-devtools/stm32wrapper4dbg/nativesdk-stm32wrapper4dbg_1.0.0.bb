SUMMARY = "Wrapper for FSBL to debug TF-A U-Boot and bare metal on MP1"
LICENSE = "GPLv2+ | BSD-3-Clause"

require stm32wrapper4dbg_${PV}.inc

inherit nativesdk
