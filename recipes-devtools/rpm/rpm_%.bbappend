FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
DEPENDS:append:class-native = " lua-native "
